# Keil uVision project PiCommand.uvprojx, settings and files
target PiCommand (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PiCommand
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51_16K_S130 -D__ASSERT_MSG -DMBED_BUILD_TIMESTAMP=1478764360.75 -DTARGET_NRF51822 --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DTARGET_NRF51822_MKIT -c -DTARGET_NORDIC -O3 -DTARGET_MCU_NRF51822 -DDEVICE_PORTOUT=1 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M0 -DTARGET_MCU_NORDIC_16K -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTARGET_MCU_NRF51 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_MCU_NRF51_16K
  c include: .; nRF51822; nRF51822/nordic; nRF51822/nordic/nrf-sdk; nRF51822/nordic/nrf-sdk/s110; nRF51822/nordic/nrf-sdk/bootloader_dfu; nRF51822/nordic/nrf-sdk/app_common; nRF51822/nordic/nrf-sdk/sd_common; nRF51822/nordic/nrf-sdk/ble; nRF51822/nordic/nrf-sdk/ble/device_manager; nRF51822/nordic/nrf-sdk/ble/ble_services; nRF51822/nordic/bootloader_dfu; nRF51822/nordic/app_common; nRF51822/nordic/ble; nRF51822/nordic/ble/ble_services; nRF51822/common; nRF51822/btle; nRF51822/btle/custom; BLE_API; BLE_API/services; BLE_API/common; BLE_API/public; mbed/.; mbed/TARGET_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/app_common; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/sd_common; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API/include; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT; mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTARGET_MCU_NRF51_16K_S130,-DARM_MATH_CM0,-DTARGET_MCU_NORDIC_16K,-DNRF51,-D__CORTEX_M0,-DTARGET_NRF51822,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTARGET_MCU_NRF51_16K,-DTARGET_NRF51822_MKIT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  group PiCommand
    ./: droid_hw.h main.cpp mbed_config.h
  group TARGET_MCU_NRF51822
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/: gpio_object.h objects.h PeripheralNames.h PortNames.h
  group TARGET_NRF51822
    mbed/TARGET_NRF51822/: cmsis.h cmsis_nvic.h compiler_abstraction.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h nordic_global.h nrf51.h nrf51822.h nrf51_bitfields.h system_nrf51822.h
  group TARGET_NRF51822_MKIT
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT/: device.h PinNames.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o mbed.ar retarget.o startup_nRF51822.o sys.o system_nrf51822.o
  group app_common
    nRF51822/nordic/nrf-sdk/app_common/: app_button.h app_error.h app_fifo.h app_gpiote.h app_scheduler.h app_timer.h app_trace.h app_uart.h app_util.h crc16.h hal_transport.h hci_mem_pool.h hci_mem_pool_internal.h hci_slip.h hci_transport.h pstorage.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/app_common/: app_button.h app_error.h app_fifo.h app_gpiote.h app_scheduler.h app_timer.h app_trace.h app_uart.h app_util.h crc16.h hal_transport.h hci_mem_pool.h hci_mem_pool_internal.h hci_slip.h hci_transport.h pstorage.h
    nRF51822/nordic/app_common/: app_gpiote.c app_scheduler.c crc16.cpp hci_mem_pool.c pstorage.cpp
  group ble
    nRF51822/nordic/ble/: ble_advdata.cpp ble_advdata_parser.cpp ble_bondmngr.cpp ble_conn_params.cpp ble_debug_assert_handler.cpp ble_error_log.cpp
    nRF51822/nordic/nrf-sdk/ble/: ble_advdata.h ble_advdata_parser.h ble_central_bondmngr.h ble_conn_params.h ble_date_time.h ble_db_discovery.h ble_debug_assert_handler.h ble_dtm.h ble_error_log.h ble_flash.h ble_racp.h ble_radio_notification.h ble_sensorsim.h
  group ble_services
    nRF51822/nordic/nrf-sdk/ble/ble_services/: ble_ans_c.h ble_bas.h ble_bas_c.h ble_bps.h ble_cscs.h ble_dfu.h ble_dis.h ble_gls.h ble_gls_db.h ble_hids.h ble_hrs.h ble_hrs_c.h ble_hts.h ble_ias.h ble_ias_c.h ble_lls.h ble_rscs.h ble_sc_ctrlpt.h ble_sensor_location.h ble_srv_common.h ble_tps.h
    nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
  group bootloader_dfu
    nRF51822/nordic/nrf-sdk/bootloader_dfu/: bootloader_types.h bootloader_util.h dfu_app_handler.h
    nRF51822/nordic/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
  group btle
    nRF51822/btle/: btle.cpp btle.h btle_advertising.cpp btle_advertising.h btle_gap.cpp btle_gap.h
  group common
    nRF51822/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    BLE_API/common/: blecommon.h BLEDevice.cpp BLEDeviceInstanceBase.h GapAdvertisingData.cpp GapAdvertisingParams.cpp GattService.cpp UUID.cpp
  group custom
    nRF51822/btle/custom/: custom_helper.cpp custom_helper.h
  group device_manager
    nRF51822/nordic/nrf-sdk/ble/device_manager/: device_manager.h
  group include
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API/include/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_mbr.h nrf_sdm.h nrf_soc.h nrf_svc.h softdevice_assert.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h toolchain.h us_ticker_api.h wait_api.h
  group nRF51822
    nRF51822/: nRF51822n.cpp nRF51822n.h nRF51Gap.cpp nRF51Gap.h nRF51GattServer.cpp nRF51GattServer.h projectconfig.h
  group nordic
    nRF51822/nordic/: ble_bondmngr_cfg.h nordic_global.h pstorage_platform.h softdevice_handler.cpp
  group nrf-sdk
    nRF51822/nordic/nrf-sdk/: nordic_common.h nrf_assert.h nrf_delay.h nrf_ecb.h nrf_gpio.h nrf_nvmc.h nrf_temp.h system_nrf51.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/: nrf_delay.h
  group public
    BLE_API/public/: BLEDevice.h CallChainOfFunctionPointersWithContext.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GattAttribute.h GattCharacteristic.h GattCharacteristicWriteCBParams.h GattServer.h GattServerEvents.h GattService.h UUID.h
  group s110
    nRF51822/nordic/nrf-sdk/s110/: ble.h ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_mbr.h nrf_sdm.h nrf_soc.h nrf_svc.h softdevice_assert.h
  group sd_common
    nRF51822/nordic/nrf-sdk/sd_common/: ant_stack_handler_types.h app_util_platform.h ble_stack_handler_types.h softdevice_handler.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/sd_common/: app_util_platform.h
  group services
    BLE_API/services/: BatteryService.h DeviceInformationService.h DFUService.cpp DFUService.h HealthThermometerService.h HeartRateService.h LinkLossService.h UARTService.cpp UARTService.h URIBeaconConfigService.h
